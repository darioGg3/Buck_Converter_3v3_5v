File: hardware/Buck_Converter.kicad_sch (KiCad schematic)
At the start: 17 parts, among them J1 SolderWire, J2 SolderWire, U1 TPS54331

Commit message: version 9
Parts:
- L1: value 39mH -> 39uH
